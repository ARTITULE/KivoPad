## boards/shields/kivopad/Kconfig.defconfig
```kconfig
if SHIELD_KIVOPAD

config ZMK_KEYBOARD_NAME
    default "KivoPad"

endif # SHIELD_KIVOPAD
```
